# Keil uVision project ISAD_II_RTOS_By_Rody.uvprojx, settings and files
target ISADII (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ISADIIMCU +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\BIN\ISADIIMCU.bin ..\OBJ\ISADIIMCU.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_CRT_SECURE_NO_WARNINGS
  c include: ..\APP;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\FWLIB\STM32F4x7_ETH_Driver\src;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\STMCore;..\FreeRTOS\Core;..\HARDWARE\HMI_DRIVE\inc;..\HARDWARE\Other\Bell;..\HARDWARE\Other\Led;..\HARDWARE\EEprom;..\HARDWARE\Flash;..\HARDWARE\TemperatureHumidity;..\HARDWARE\Pressure;..\HARDWARE\GPIO;..\SYSTEM\Timer;..\Shell;..\FATFS;..\FATFS\option;..\BAS;..\HARDWARE\ETHERNET;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\netif;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip_app\lwip_comm;..\LWIP\arch;..\MALLOC;..\LWIP;..\LWIP\lwip_app;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\udp_demo;..\FILE-OPERATE;..\HARDWARE\COMM
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APPLication
    ../APP/: Main.c BSP.c APP.c App_Comm.c
  group APP\Prameters
    ../APP/: App_Params.c
  group HARDWARE\HMI
    ../HARDWARE/HMI_DRIVE/src/: cmd_queue.c hmi_APP.c hmi_driver.c hmi_usart.c
  group HARDWARE\OTHER
    ../HARDWARE/Other/Bell/: Bell.c
    ../HARDWARE/Other/Led/: led.c
  group HARDWARE\FLASH_EEPROM
    ../HARDWARE/Flash/: w25qxx.c Flash_spi.c
    ../HARDWARE/EEprom/: 24cxx.c EEP_I2C.c
  group HARDWARE\SENSOR
    ../HARDWARE/TemperatureHumidity/: DHTxx.c
    ../HARDWARE/Pressure/: Pressure.c
  group HARDWARE\GPIO
    ../HARDWARE/GPIO/: GPIO.c
  group HARDWARE\ETHERNET
    ../HARDWARE/ETHERNET/: lan8720.c
  group HARDWARE\COMM
    ../HARDWARE/COMM/: bsp_esp8266.c bsp_hc05.c bsp_ethernet.c bsp_comm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/Timer/: Timer.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_iwdg.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Core/: sys_wdg.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group STMCore
    ../STMCore/: stm32f4xx_it.c system_stm32f4xx.c
  group Shell
    ../Shell/: shell.c shell_cmd_list.c shell_ext.c
  group BAS
    ../BAS/: sdio_sdcard.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: cc936.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group FILE-OPERAT
    ../FILE-OPERATE/: file_operate.c
